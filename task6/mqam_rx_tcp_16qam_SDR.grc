options:
  parameters:
    author: Luis
    generate_options: qt_gui
    id: mqam_etapa1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: '16'
  states: {}
- name: ber_window
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: bits_per_symbol
  id: variable
  parameters:
    value: int(math.log2(M))
  states: {}
- name: costas
  id: variable_qtgui_range
  parameters:
    label: Ancho costas
    start: '0.001'
    step: '0.001'
    stop: '0.02'
    value: '0.001'
  states: {}
- name: fine_freq
  id: variable_qtgui_range
  parameters:
    label: Corrección fina [Hz]
    start: '-3000'
    step: '10'
    stop: '3000'
    value: '0'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: noise_voltage
  id: variable
  parameters:
    value: 10**(-snr_db/20.0)
  states: {}
- name: qam_const
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: |-
      firdes.root_raised_cosine(
          sps,
          samp_rate,
          symbol_rate,
          rolloff,
          11*sps
      )
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Ganancia RTL-SDR [dB]
    start: '0'
    step: '1'
    stop: '50'
    value: '40'
  states: {}
- name: rx_scale
  id: variable_qtgui_range
  parameters:
    label: Corrección RX  en escala
    start: '0.1'
    step: '0.1'
    stop: '20'
    value: '0.2'
  states: {}
- name: rx_tune
  id: variable_qtgui_range
  parameters:
    label: Corrección RX [Hz]
    start: '-100000'
    step: '1000'
    stop: '100000'
    value: '-36000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sample_phase
  id: variable_qtgui_range
  parameters:
    label: Fase de muestreo
    start: '0'
    step: '1'
    stop: '9'
    value: '2'
  states: {}
- name: sample_phase_sdr
  id: variable_qtgui_range
  parameters:
    label: Fase de SDR
    start: '0'
    step: '1'
    stop: '9'
    value: '0'
  states: {}
- name: snr_db
  id: variable_qtgui_range
  parameters:
    label: SNR aproximada [dB]
    start: '0'
    step: '1'
    stop: '40'
    value: '40'
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate / symbol_rate)
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 2e5
  states: {}
- name: ted_gain
  id: variable_qtgui_range
  parameters:
    label: Ganancia esperada TED
    start: '0.01'
    step: '0.01'
    stop: '3'
    value: '1'
  states: {}
- name: tx_delay
  id: variable_qtgui_range
  parameters:
    label: Alineación TX-RX
    start: '0'
    step: '1'
    stop: '200'
    value: '5'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '100'
    rate: '1e-5'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: sample_phase_sdr
    type: complex
  states: {state: disabled}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: sps
    type: complex
  states: {state: disabled}
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    n: '997'
    type: byte
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '10000'
    max_iter: '4000'
    scale: 1.0/10000
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0/sps
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Mult const automatico
    const: rx_scale
    type: complex
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    comment: Repack RX
    endianness: gr.GR_MSB_FIRST
    k: bits_per_symbol
    l: '8'
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noise_voltage
    seed: '0'
    taps: '[1.0 + 0.0j]'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1'
    long_form: 'True'
    type: cc
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: qam_const.points()
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qam_const
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: qam_const
    fmax: '1.5'
    fmin: '-1.5'
    loop_bw: '0.02'
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.01'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '32'
    rolloff: rolloff
    samps_per_sym: sps
    type: cc
    w: '0.04'
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.02'
    max_dev: '2.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '0.3'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: '300000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: '50000'
    win: window.WIN_HAMMING
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio.filter import firdes
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: interp_fir_filter_xxx_1
  id: interp_fir_filter_xxx
  parameters:
    comment: FIR Filter RX
    interp: '1'
    taps: rrc_taps
    type: ccc
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1316'
    port: '6001'
    send_eof: 'False'
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"ConstelacionRX Manual"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_2_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    name: '"RX con Symbol Sync"'
    size: '1024'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_2_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    name: '"RX con PRE - Symbol Sync"'
    size: '1024'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_2_0_1
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    name: '"Símbolos RX decididos"'
    size: '1024'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    name: '"Frequency Sink RF"'
    type: complex
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '16'
    size: '1024'
    type: float
    xmax: '15.5'
    xmin: '-0.5'
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '15'
    min: '0'
    name: '"Salida 0 a 15"'
    type: byte
  states: {state: disabled}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Potencia media RX"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"Numeros recibidos"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '64'
    srate: symbol_rate
    type: float
    ymax: '16'
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Limite de frecuencia"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '0.6'
    ymin: '-0.6'
  states: {state: disabled}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: error
    label2: phase
    name: '"Prueba constelation"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_4
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    name: '"Señal recibida Tiempo"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq + rx_tune
    dev_args: driver=rtlsdr
    gain: rx_gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Rama_manual
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Rama_manual
  states: {state: disabled}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_char_to_float_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_delay_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_keep_one_in_n_1, '0', qtgui_number_sink_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_number_sink_1, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_repack_bits_bb_1, '0', blocks_uchar_to_float_0, '0']
- [blocks_repack_bits_bb_1, '0', network_udp_sink_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [channels_channel_model_0, '0', interp_fir_filter_xxx_1, '0']
- [dc_blocker_xx_0, '0', analog_agc_xx_0, '0']
- [dc_blocker_xx_0, '0', channels_channel_model_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_const_sink_x_2_0_1, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_keep_one_in_n_1, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_constellation_receiver_cb_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_constellation_receiver_cb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_constellation_receiver_cb_0, '1', qtgui_time_sink_x_3, '0']
- [digital_constellation_receiver_cb_0, '2', qtgui_time_sink_x_3, '1']
- [digital_constellation_receiver_cb_0, '3', qtgui_time_sink_x_2, '0']
- [digital_constellation_receiver_cb_0, '4', qtgui_const_sink_x_1, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_2_0, '0']
- [digital_fll_band_edge_cc_0, '0', channels_channel_model_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_receiver_cb_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [filter_fft_low_pass_filter_0, '0', channels_channel_model_0, '0']
- [interp_fir_filter_xxx_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [interp_fir_filter_xxx_1, '0', qtgui_const_sink_x_2_0_0, '0']
- [interp_fir_filter_xxx_1, '0', virtual_sink_0, '0']
- [soapy_rtlsdr_source_0, '0', dc_blocker_xx_0, '0']
- [soapy_rtlsdr_source_0, '0', digital_fll_band_edge_cc_0, '0']
- [soapy_rtlsdr_source_0, '0', filter_fft_low_pass_filter_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_time_sink_x_4, '0']
- [virtual_source_0, '0', blocks_delay_0, '0']
- [zeromq_pull_source_0, '0', dc_blocker_xx_0, '0']
- [zeromq_pull_source_0, '0', digital_fll_band_edge_cc_0, '0']
- [zeromq_pull_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
