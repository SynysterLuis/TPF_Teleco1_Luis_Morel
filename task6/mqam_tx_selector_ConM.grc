options:
  parameters:
    author: Luis
    generate_options: qt_gui
    id: mqam_TX_TCP
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: '[8, 16, 32, 64, 128, 256][m_sel]'
  states: {}
- name: VGA
  id: variable_qtgui_range
  parameters:
    label: Ajuste VGA
    start: '5'
    step: '1'
    stop: '20'
    value: '10'
  states: {}
- name: ber_window
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: bits_per_symbol
  id: variable
  parameters:
    value: int(math.log2(M))
  states: {}
- name: freq
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: m_sel
  id: variable_qtgui_chooser
  parameters:
    label: Orden M-QAM
    labels: '["8-QAM", "16-QAM", "32-QAM",  "64-QAM", "128-QAM", "256-QAM"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5]'
    type: int
    value: '0'
  states: {}
- name: medium
  id: variable_qtgui_chooser
  parameters:
    label: Medio de transmisión
    labels: '["TCP / ZMQ", "SDR"]'
    num_opts: '0'
    options: '[0, 1]'
    type: int
    value: '0'
  states: {}
- name: noise_voltage
  id: variable
  parameters:
    value: 10**(-snr_db/20.0)
  states: {}
- name: qam128_points
  id: variable
  parameters:
    value: rectangular_qam_points(128)
  states: {}
- name: qam256_points
  id: variable
  parameters:
    value: rectangular_qam_points(256)
  states: {}
- name: qam32_points
  id: variable
  parameters:
    value: rectangular_qam_points(32)
  states: {}
- name: qam64_points
  id: variable
  parameters:
    value: rectangular_qam_points(64)
  states: {}
- name: qam8_points
  id: variable
  parameters:
    value: rectangular_qam_points(8)
  states: {}
- name: qam_const
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: |-
      firdes.root_raised_cosine(
          sps,
          samp_rate,
          symbol_rate,
          rolloff,
          11*sps
      )
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sample_phase
  id: variable_qtgui_range
  parameters:
    label: Fase de muestreo
    start: '0'
    step: '1'
    stop: '9'
    value: '2'
  states: {}
- name: snr_db
  id: variable_qtgui_range
  parameters:
    label: SNR aproximada [dB]
    start: '0'
    step: '1'
    stop: '40'
    value: '40'
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate / symbol_rate)
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: ted_gain
  id: variable_qtgui_range
  parameters:
    label: Ganancia esperada TED
    start: '0.01'
    step: '0.01'
    stop: '1.0'
    value: '1'
  states: {}
- name: tx_amp
  id: variable_qtgui_range
  parameters:
    label: Ganancia TXAMP
    start: '0.01'
    step: '0.01'
    stop: '0.2'
    value: '0.2'
  states: {}
- name: tx_delay
  id: variable_qtgui_range
  parameters:
    label: Alineación TX-RX
    start: '0'
    step: '1'
    stop: '200'
    value: '5'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters:
    comment: TX
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_amp
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    comment: Repack TX
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: bits_per_symbol
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: medium
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '6'
    output_index: m_sel
    type: byte
  states: {}
- name: blocks_selector_2
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: m_sel
    num_inputs: '6'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: qam_const.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: qam8_points
  states: {}
- name: digital_chunks_to_symbols_xx_0_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: qam32_points
  states: {}
- name: digital_chunks_to_symbols_xx_0_2
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: qam64_points
  states: {}
- name: digital_chunks_to_symbols_xx_0_3
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: qam128_points
  states: {}
- name: digital_chunks_to_symbols_xx_0_4
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: qam256_points
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio.filter import firdes
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: import_1_0
  id: import
  parameters:
    imports: |-
      def rectangular_qam_points(m):
          k = int(math.log2(m))
          bits_i = (k + 1) // 2
          bits_q = k // 2
          ni = 2**bits_i
          nq = 2**bits_q

          raw = [
              complex(2*i-(ni-1), 2*q-(nq-1))
              for q in range(nq)
              for i in range(ni)
          ]

          scale = math.sqrt(
              sum(abs(p)**2 for p in raw) / len(raw)
          )

          return [p/scale for p in raw]
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: rrc_taps
    type: ccc
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: '1316'
    port: '6000'
    src_zeros: 'False'
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    name: '"Constellation TX ideal"'
    size: '1024'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    label1: RX sin sincronizar
    name: '"Señal recibida sobremuestreada"'
    size: '1024'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    label1: TX limpia
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: I transmitida
    label2: Q transmitida
    nconnections: '2'
    size: '1000'
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: soapy_hackrf_sink_0_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: freq
    dev_args: driver=hackrf
    samp_rate: samp_rate
    type: fc32
    vga: VGA
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_0, '1']
- [blocks_multiply_const_vxx_0, '0', soapy_hackrf_sink_0_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_selector_1, '0']
- [blocks_selector_0, '0', blocks_throttle2_0, '0']
- [blocks_selector_0, '1', blocks_multiply_const_vxx_0, '0']
- [blocks_selector_1, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [blocks_selector_1, '1', digital_chunks_to_symbols_xx_0, '0']
- [blocks_selector_1, '2', digital_chunks_to_symbols_xx_0_1, '0']
- [blocks_selector_1, '3', digital_chunks_to_symbols_xx_0_2, '0']
- [blocks_selector_1, '4', digital_chunks_to_symbols_xx_0_3, '0']
- [blocks_selector_1, '5', digital_chunks_to_symbols_xx_0_4, '0']
- [blocks_selector_2, '0', interp_fir_filter_xxx_0, '0']
- [blocks_selector_2, '0', qtgui_const_sink_x_0, '0']
- [blocks_throttle2_0, '0', blocks_complex_to_float_0, '0']
- [blocks_throttle2_0, '0', qtgui_const_sink_x_1, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', zeromq_push_sink_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_selector_2, '1']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_selector_2, '0']
- [digital_chunks_to_symbols_xx_0_1, '0', blocks_selector_2, '2']
- [digital_chunks_to_symbols_xx_0_2, '0', blocks_selector_2, '3']
- [digital_chunks_to_symbols_xx_0_3, '0', blocks_selector_2, '4']
- [digital_chunks_to_symbols_xx_0_4, '0', blocks_selector_2, '5']
- [interp_fir_filter_xxx_0, '0', blocks_selector_0, '0']
- [network_udp_source_0, '0', blocks_repack_bits_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
