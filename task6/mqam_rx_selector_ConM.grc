options:
  parameters:
    author: Luis
    generate_options: qt_gui
    id: mqam_RX_TCP
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: '[8, 16, 32, 64, 128, 256][m_sel]'
  states: {}
- name: ber_window
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: bits_per_symbol
  id: variable
  parameters:
    value: int(math.log2(M))
  states: {}
- name: freq
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: m_sel
  id: variable_qtgui_chooser
  parameters:
    label: Orden M-QAM
    labels: '["8-QAM", "16-QAM", "32-QAM",  "64-QAM", "128-QAM", "256-QAM"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5]'
    type: int
    value: '0'
  states: {}
- name: medium
  id: variable_qtgui_chooser
  parameters:
    label: Medio de transmisión
    labels: '["TCP / ZMQ", "SDR"]'
    num_opts: '0'
    options: '[0, 1]'
    type: int
    value: '0'
  states: {}
- name: noise_voltage
  id: variable
  parameters:
    value: 10**(-snr_db/20.0)
  states: {}
- name: qam128_const
  id: variable
  parameters:
    value: |-
      digital.constellation_calcdist(
          qam128_points,
          list(range(len(qam128_points))),
          1,
          1
      ).base()
  states: {}
- name: qam128_points
  id: variable
  parameters:
    value: rectangular_qam_points(128)
  states: {}
- name: qam256_const
  id: variable
  parameters:
    value: |-
      digital.constellation_calcdist(
          qam256_points,
          list(range(len(qam256_points))),
          1,
          1
      ).base()
  states: {}
- name: qam256_points
  id: variable
  parameters:
    value: rectangular_qam_points(256)
  states: {}
- name: qam32_const
  id: variable
  parameters:
    value: |-
      digital.constellation_calcdist(
          qam32_points,
          list(range(len(qam32_points))),
          1,
          1
      ).base()
  states: {}
- name: qam32_points
  id: variable
  parameters:
    value: rectangular_qam_points(32)
  states: {}
- name: qam64_const
  id: variable
  parameters:
    value: |-
      digital.constellation_calcdist(
          qam64_points,
          list(range(len(qam64_points))),
          1,
          1
      ).base()
  states: {}
- name: qam64_points
  id: variable
  parameters:
    value: rectangular_qam_points(64)
  states: {}
- name: qam8_const
  id: variable
  parameters:
    value: |-
      digital.constellation_calcdist(
          qam8_points,
          list(range(len(qam8_points))),
          1,
          1
      ).base()
  states: {}
- name: qam8_points
  id: variable
  parameters:
    value: rectangular_qam_points(8)
  states: {}
- name: qam_const
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: |-
      firdes.root_raised_cosine(
          sps,
          samp_rate,
          symbol_rate,
          rolloff,
          11*sps
      )
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sample_phase
  id: variable_qtgui_range
  parameters:
    label: Fase de muestreo
    start: '0'
    step: '1'
    stop: '9'
    value: '2'
  states: {}
- name: snr_db
  id: variable_qtgui_range
  parameters:
    label: SNR aproximada [dB]
    start: '0'
    step: '1'
    stop: '40'
    value: '40'
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate / symbol_rate)
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: ted_gain
  id: variable_qtgui_range
  parameters:
    label: Ganancia esperada TED
    start: '0.01'
    step: '0.01'
    stop: '1.0'
    value: '1'
  states: {}
- name: tx_delay
  id: variable_qtgui_range
  parameters:
    label: Alineación TX-RX
    start: '0'
    step: '1'
    stop: '200'
    value: '5'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Mult const automatico
    const: 1.0 / sps
    type: complex
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    comment: Repack RX
    endianness: gr.GR_MSB_FIRST
    k: bits_per_symbol
    l: '8'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: medium
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '6'
    output_index: m_sel
    type: complex
  states: {}
- name: blocks_selector_1_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: m_sel
    num_inputs: '6'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noise_voltage
    seed: '0'
    taps: '[1.0 + 0.0j]'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qam_const
  states: {}
- name: digital_constellation_decoder_cb_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qam8_const
  states: {}
- name: digital_constellation_decoder_cb_1_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qam256_const
  states: {}
- name: digital_constellation_decoder_cb_1_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qam128_const
  states: {}
- name: digital_constellation_decoder_cb_1_2
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qam32_const
  states: {}
- name: digital_constellation_decoder_cb_1_3
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qam64_const
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '32'
    rolloff: rolloff
    samps_per_sym: sps
    type: cc
    w: '0.04'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: 2*math.pi/100
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: ted_gain
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio.filter import firdes
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: import_1_0
  id: import
  parameters:
    imports: |-
      def rectangular_qam_points(m):
          k = int(math.log2(m))
          bits_i = (k + 1) // 2
          bits_q = k // 2
          ni = 2**bits_i
          nq = 2**bits_q

          raw = [
              complex(2*i-(ni-1), 2*q-(nq-1))
              for q in range(nq)
              for i in range(ni)
          ]

          scale = math.sqrt(
              sum(abs(p)**2 for p in raw) / len(raw)
          )

          return [p/scale for p in raw]
  states: {}
- name: interp_fir_filter_xxx_1
  id: interp_fir_filter_xxx
  parameters:
    comment: FIR Filter RX
    interp: '1'
    taps: rrc_taps
    type: ccc
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1316'
    port: '6001'
    send_eof: 'False'
    type: byte
  states: {}
- name: qtgui_const_sink_x_2_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    name: '"RX con Symbol Sync"'
    size: '1024'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '16'
    size: '1024'
    type: float
    xmax: '15.5'
    xmin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '64'
    srate: symbol_rate
    type: float
    ymax: '16'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    dev_args: driver=rtlsdr
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_repack_bits_bb_1, '0', network_udp_sink_0, '0']
- [blocks_selector_0, '0', interp_fir_filter_xxx_1, '0']
- [blocks_selector_1, '0', digital_constellation_decoder_cb_1, '0']
- [blocks_selector_1, '1', digital_constellation_decoder_cb_0, '0']
- [blocks_selector_1, '2', digital_constellation_decoder_cb_1_2, '0']
- [blocks_selector_1, '3', digital_constellation_decoder_cb_1_3, '0']
- [blocks_selector_1, '4', digital_constellation_decoder_cb_1_1, '0']
- [blocks_selector_1, '5', digital_constellation_decoder_cb_1_0, '0']
- [blocks_selector_1_0, '0', blocks_char_to_float_0, '0']
- [blocks_selector_1_0, '0', blocks_repack_bits_bb_1, '0']
- [channels_channel_model_0, '0', blocks_selector_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_selector_1_0, '1']
- [digital_constellation_decoder_cb_1, '0', blocks_selector_1_0, '0']
- [digital_constellation_decoder_cb_1_0, '0', blocks_selector_1_0, '5']
- [digital_constellation_decoder_cb_1_1, '0', blocks_selector_1_0, '4']
- [digital_constellation_decoder_cb_1_2, '0', blocks_selector_1_0, '2']
- [digital_constellation_decoder_cb_1_3, '0', blocks_selector_1_0, '3']
- [digital_fll_band_edge_cc_0, '0', blocks_selector_0, '1']
- [digital_symbol_sync_xx_0, '0', blocks_selector_1, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_2_0, '0']
- [interp_fir_filter_xxx_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [soapy_rtlsdr_source_0, '0', digital_fll_band_edge_cc_0, '0']
- [zeromq_pull_source_0, '0', channels_channel_model_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
