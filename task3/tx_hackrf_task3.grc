options:
  parameters:
    author: Luis Morel
    generate_options: qt_gui
    id: task3_tx_hackrf
    output_language: python
    title: task3_tx
  states: {}

blocks:
- name: VGA
  id: variable_qtgui_range
  parameters:
    label: VGA
    start: '10'
    step: '1'
    stop: '47'
    value: '20'
  states: {}
- name: bt
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_amp
  id: variable_qtgui_range
  parameters:
    label: Ganancia tx
    start: '0.01'
    step: '0.01'
    stop: '0.5'
    value: '0.4'
  states: {}
- name: udp_payload
  id: variable
  parameters:
    value: '1316'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_amp
    type: complex
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: bt
    samples_per_symbol: sps
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: udp_payload
    port: '6000'
    src_zeros: 'False'
    type: byte
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: center_freq
    comment: Envio por HackRf
    dev_args: driver=hackrf
    samp_rate: samp_rate
    type: fc32
    vga: VGA
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', soapy_hackrf_sink_0, '0']
- [digital_gmsk_mod_0, '0', blocks_multiply_const_vxx_0, '0']
- [network_udp_source_0, '0', digital_gmsk_mod_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
