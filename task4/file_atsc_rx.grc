options:
  parameters:
    author: Luis Morel
    category: Custom
    generate_options: qt_gui
    id: file_atsc_rx
    output_language: python
    run_options: run
    title: ATSC_RX - Task 4
  states: {}

blocks:
- name: antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: atsc_sym_rate
  id: variable
  parameters:
    value: 4.5e6/286*684
  states: {}
- name: duration
  id: variable
  parameters:
    value: '30'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 605e6
  states: {}
- name: gain
  id: variable
  parameters:
    value: '18'
  states: {}
- name: oversampled_rate
  id: variable
  parameters:
    value: atsc_sym_rate*sps
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 6.25e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '1.1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: mpeg.ts
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Luis\Documents\9semestre\Teleco1\TPF\task4\atsc.cfile
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: atsc_sym_rate
    type: complex
  states: {}
- name: dtv_atsc_rx_0
  id: dtv_atsc_rx
  parameters:
    rate: atsc_sym_rate
    sps: '1.5'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '8192'
    name: '"Atsc Spectrum"'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', dtv_atsc_rx_0, '0']
- [blocks_throttle2_0, '0', dtv_atsc_rx_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [dtv_atsc_rx_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
